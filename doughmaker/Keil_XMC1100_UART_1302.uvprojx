# Keil uVision project Keil_XMC1100_UART_1302.uvprojx, settings and files
target Keil_XMC1100_UART_1302 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: XMC1100-Q024x0064 Infineon
  pack: Infineon.XMC1000_DFP.2.5.1
  cpu: IRAM(0x20000000,0x3FFC) IROM(0x10001000,0x10000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: Keil_XMC1100_UART_1302 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: .\Source;.\Startup;.\MCUINIT;.\HARDWARE;.\MCUINIT\Init;.\HARDWARE\24CXX;.\HARDWARE\IIC;.\HARDWARE\TIMER;.\HARDWARE\DS18B20;.\WDT
  memory RVCT4: ROM 0x10001000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3ffc
  group Startup
    ./Startup/: startup_XMC1100.s system_XMC1100.c
  group MCUINT
    ./: Main.c
    ./MCUINIT/: datatanrsfer.c ERU0.c GPIO.c MCUInit.c UART.c delay.c
    ./MCUINIT/Init/: init.c
    ./HARDWARE/TIMER/: timer.c
    ./HARDWARE/DS18B20/: ds18b20.c
    ./WDT/: WDT.c
  group HARDWARE
    ./HARDWARE/24CXX/: 24cxx.c
    ./HARDWARE/IIC/: myiic.c
software components: CMSIS:CORE 5.0.0
